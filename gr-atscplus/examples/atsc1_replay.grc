options:
  parameters:
    id: atsc1_replay
    title: 'ATSC 1.0 (8-VSB) receiver: capture to transport stream'
    author: gr-atscplus
    generate_options: no_gui
    output_language: python
    run_options: run
    description: The production STVT chain, block for block, on a capture file.
  states: {}

blocks:
- name: sps
  id: variable
  parameters:
    value: '1.1'
    comment: 'samples per symbol into the sync (production: 1.1)'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: (4.5e6/286*684)*sps
  states: {}
- name: capture
  id: parameter
  parameters:
    label: Capture (.cf32, 8 MS/s)
    type: str
    value: '"capture.cf32"'
    short_id: c
  states: {}
- name: out
  id: parameter
  parameters:
    label: Transport stream out
    type: str
    value: '"out.ts"'
    short_id: o
  states: {}
- name: src
  id: blocks_file_source
  parameters:
    type: complex
    file: capture
    repeat: 'False'
  states: {}
- name: ts
  id: blocks_file_sink
  parameters:
    type: byte
    file: out
  states: {}
- name: fold
  id: import
  parameters:
    imports: import os; os.environ.setdefault('STVT_FPLL_FOLD', '1')
    comment: 'production setting: DC block + AGC folded into the FPLL'
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '32768.0'
    comment: the chain was tuned on int16-scale samples
  states: {}
- name: resamp
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: '25'
    decim: '32'
    comment: 8 MS/s -> 6.25 MS/s
  states: {}
- name: rxf
  id: dtv_atsc_rx_filter
  parameters:
    rate: 6.25e6
    sps: sps
    comment: RRC matched filter; out at sps x symbol rate
  states: {}
- name: fpll
  id: atscplus_atsc_fpll_tight
  parameters:
    rate: out_rate
    alpha: '0.001'
    afc_tau_us: '25'
  states: {}
- name: sync
  id: atscplus_atsc_sync_soft
  parameters:
    rate: out_rate
  states: {}
- name: fsc
  id: atscplus_atsc_fs_checker_inst
  parameters: {}
  states: {}
- name: eq
  id: atscplus_atsc_equalizer_long
  parameters: {}
  states: {}
- name: vit
  id: atscplus_atsc_viterbi_soft
  parameters: {}
  states: {}
- name: dei
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {}
- name: rs
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {}
- name: derand
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {}
- name: depad
  id: dtv_atsc_depad
  parameters: {}
  states: {}
- name: s2v
  id: blocks_stream_to_vector
  parameters:
    type: byte
    num_items: '188'
  states: {}
- name: tei
  id: atscplus_tei_scrub
  parameters:
    scrub: 'True'
    report_s: '1.0'
    comment: uncorrectable packets -> NULL; the liveness count
  states: {}
- name: v2s
  id: blocks_vector_to_stream
  parameters:
    type: byte
    num_items: '188'
  states: {}

connections:
- [src, '0', scale, '0']
- [v2s, '0', ts, '0']
- [scale, '0', resamp, '0']
- [resamp, '0', rxf, '0']
- [rxf, '0', fpll, '0']
- [fpll, '0', sync, '0']
- [sync, '0', fsc, '0']
- [fsc, '0', eq, '0']
- [fsc, '1', eq, '1']
- [eq, '0', vit, '0']
- [eq, '1', vit, '1']
- [vit, '0', dei, '0']
- [vit, '1', dei, '1']
- [dei, '0', rs, '0']
- [dei, '1', rs, '1']
- [rs, '0', derand, '0']
- [rs, '1', derand, '1']
- [derand, '0', depad, '0']
- [depad, '0', s2v, '0']
- [s2v, '0', tei, '0']
- [tei, '0', v2s, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
