options:
  parameters:
    id: atsc1_live_qt
    title: ATSC 1.0 (8-VSB) television in GNU Radio
    author: gr-atscplus
    generate_options: qt_gui
    output_language: python
    description: The production STVT chain on a radio, with the picture in the window.
  states: {}

blocks:
- name: sps
  id: variable
  parameters:
    value: '1.1'
    comment: 'samples per symbol into the sync (production: 1.1)'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: (4.5e6/286*684)*sps
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Channel centre (Hz)
    type: eng_float
    value: 600e6
    short_id: f
  states: {}
- name: driver
  id: parameter
  parameters:
    label: SoapySDR driver
    type: str
    value: '"sdrplay"'
    short_id: d
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna port
    type: str
    value: '""'
    short_id: a
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Overall gain (dB)
    type: eng_float
    value: '30'
    short_id: g
    comment: or the gain elements, from gr-rxtune
  states: {}
- name: ts_out
  id: parameter
  parameters:
    label: Also record the TS to
    type: str
    value: '""'
    short_id: o
  states: {}
- name: udp_port
  id: parameter
  parameters:
    label: UDP port for the player
    type: intx
    value: '5004'
    short_id: p
  states: {}
- name: src
  id: soapy_custom_source
  parameters:
    driver: driver
    type: fc32
    dev_args: '""'
    samp_rate: 8e6
    center_freq0: freq
    bandwidth0: 8e6
    antenna0: antenna
    gain0: gain
    minoutbuf: '4194304'
    comment: 8 MS/s, as the production chain captures
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"channel (baseband)"'
    fftsize: '2048'
    fc: '0'
    bw: 8e6
    average: '0.05'
    gui_hint: 0,0,1,1
  states: {}
- name: probe
  id: atscplus_eq_probe
  parameters:
    rate_hz: '5'
    segments: '48'
    eq_getter: 'lambda: self.eq'
    name: '"MER"'
    comment: dial for gr-rxtune + the panel
  states: {}
- name: panel
  id: atscplus_vsb_panel
  parameters:
    label: '"ATSC 1.0 / 8-VSB"'
    cliff_db: '15.2'
    gui_hint: 1,0,1,1
  states: {}
- name: udp
  id: network_udp_sink
  parameters:
    type: byte
    addr: '"127.0.0.1"'
    port: udp_port
    header: '0'
    payloadsize: '1316'
    send_eof: 'False'
    comment: 7 TS packets per datagram
  states: {}
- name: video
  id: atscplus_video_pane
  parameters:
    url: '"udp://127.0.0.1:"+str(udp_port)+"?fifo_size=1000000&overrun_nonfatal=1"'
    player: '"mpv"'
    vid: '0'
    aid: '0'
    player_args: '""'
    start_delay_s: '4'
    gui_hint: 0,1,2,1
  states: {}
- name: ts
  id: blocks_file_sink
  parameters:
    type: byte
    file: ts_out
    comment: empty name = no file
  states: {}
- name: fold
  id: import
  parameters:
    imports: import os; os.environ.setdefault('STVT_FPLL_FOLD', '1')
    comment: 'production setting: DC block + AGC folded into the FPLL'
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: '32768.0'
    comment: the chain was tuned on int16-scale samples
  states: {}
- name: resamp
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: '25'
    decim: '32'
    comment: 8 MS/s -> 6.25 MS/s
  states: {}
- name: rxf
  id: dtv_atsc_rx_filter
  parameters:
    rate: 6.25e6
    sps: sps
    comment: RRC matched filter; out at sps x symbol rate
  states: {}
- name: fpll
  id: atscplus_atsc_fpll_tight
  parameters:
    rate: out_rate
    alpha: '0.001'
    afc_tau_us: '25'
  states: {}
- name: sync
  id: atscplus_atsc_sync_soft
  parameters:
    rate: out_rate
  states: {}
- name: fsc
  id: atscplus_atsc_fs_checker_inst
  parameters: {}
  states: {}
- name: eq
  id: atscplus_atsc_equalizer_long
  parameters: {}
  states: {}
- name: vit
  id: atscplus_atsc_viterbi_soft
  parameters: {}
  states: {}
- name: dei
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {}
- name: rs
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {}
- name: derand
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {}
- name: depad
  id: dtv_atsc_depad
  parameters: {}
  states: {}
- name: s2v
  id: blocks_stream_to_vector
  parameters:
    type: byte
    num_items: '188'
  states: {}
- name: tei
  id: atscplus_tei_scrub
  parameters:
    scrub: 'True'
    report_s: '1.0'
    comment: uncorrectable packets -> NULL; the liveness count
  states: {}
- name: v2s
  id: blocks_vector_to_stream
  parameters:
    type: byte
    num_items: '188'
  states: {}

connections:
- [src, '0', scale, '0']
- [src, '0', spectrum, '0']
- [eq, '0', probe, '0']
- [probe, dial, panel, dial]
- [probe, symbols, panel, symbols]
- [probe, taps, panel, taps]
- [tei, stats, panel, stats]
- [v2s, '0', udp, '0']
- [v2s, '0', ts, '0']
- [scale, '0', resamp, '0']
- [resamp, '0', rxf, '0']
- [rxf, '0', fpll, '0']
- [fpll, '0', sync, '0']
- [sync, '0', fsc, '0']
- [fsc, '0', eq, '0']
- [fsc, '1', eq, '1']
- [eq, '0', vit, '0']
- [eq, '1', vit, '1']
- [vit, '0', dei, '0']
- [vit, '1', dei, '1']
- [dei, '0', rs, '0']
- [dei, '1', rs, '1']
- [rs, '0', derand, '0']
- [rs, '1', derand, '1']
- [derand, '0', depad, '0']
- [depad, '0', s2v, '0']
- [s2v, '0', tei, '0']
- [tei, '0', v2s, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
